# Keil uVision project ucosii_practice.uvprojx, settings and files
target ucosii_practice (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ucosii_practice
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx, USE_STDPERIPH_DRIVER, ARM_MATH_CM4, __TARGET_FPU_VFP, __FPU_PRESENT=1
  c include: ..\..\src\MCU\CMSIS_M4;..\..\src\MCU\STM32F4XX;..\..\src\MCU\STM32F4xx_DSP_StdPeriph\inc;..\..\src\ucos_ii;..\..\src\ucos_ii_cfg;..\..\src\ucos_ii\Ports\ARM-Cortex-M4\RealView;..\..\src\ucos_ii_lib;..\..\src\ucos_ii_cpu;..\..\src\ucos_ii_cpu\ARM-Cortex-M4\RealView;..\..\src\bsp;..\..\src\app
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ../../src/app/: main.c led.c
  group cmsis
    ../../src/MCU/CMSIS_M4/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h arm_cortexM4lf_math.lib
  group stm32f4xx
    ../../src/MCU/STM32F4XX/: system_stm32f4xx.c stm32f4xx.h stm32f4xx_conf.h system_stm32f4xx.h startup_stm32f40xx.s
  group stm32f4xx_std_periph
    ../../src/MCU/STM32F4xx_DSP_StdPeriph/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../../src/MCU/STM32F4xx_DSP_StdPeriph/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_cec.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dfsdm.h stm32f4xx_dma.h stm32f4xx_dma2d.h stm32f4xx_dsi.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_flash_ramfunc.h stm32f4xx_fmc.h stm32f4xx_fmpi2c.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_lptim.h stm32f4xx_ltdc.h stm32f4xx_pwr.h stm32f4xx_qspi.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sai.h stm32f4xx_sdio.h stm32f4xx_spdifrx.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
  group ucos_ii/core
    ../../src/ucos_ii/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c os.h ucos_ii.h
  group ucos_ii/port
    ../../src/ucos_ii/Ports/ARM-Cortex-M4/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group ucos_ii/cfg
    ../../src/ucos_ii_cfg/: app_cfg.h cpu_cfg.h os_cfg.h
    ../../src/app/ucos_interface/: app_hooks.c
  group ucos_ii/lib
    ../../src/ucos_ii_lib/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../../src/ucos_ii_lib/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group ucos_ii/cpu
    ../../src/ucos_ii_cpu/: cpu_core.c cpu_core.h cpu_def.h
    ../../src/ucos_ii_cpu/ARM-Cortex-M4/RealView/: cpu.h cpu_a.asm cpu_c.c
  group bsp
    ../../src/bsp/: cpu_bsp.c bsp.c
