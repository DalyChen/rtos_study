# Keil uVision project ucosii_example.uvprojx, settings and files
target ucosii_example (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ucosii_practice
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx, USE_STDPERIPH_DRIVER, ARM_MATH_CM4, __TARGET_FPU_VFP, __FPU_PRESENT=1
  c include: ..\..\src\ucos_inc\mcu\CMSIS_M4;..\..\src\ucos_inc\mcu\STM32F4XX;..\..\src\ucos_inc\mcu\STM32F4xx_DSP_StdPeriph;..\..\src\ucos_inc\ucos_ii_bsp;..\..\src\ucos_inc\ucos_ii_cfg;..\..\src\ucos_inc\ucos_ii_core;..\..\src\ucos_inc\ucos_ii_core\ARM-Cortex-M4\RealView;..\..\src\ucos_inc\ucos_ii_cpu;..\..\src\ucos_inc\ucos_ii_cpu\ARM-Cortex-M4\RealView;..\..\src\ucos_inc\ucos_ii_lib;..\..\src\ucos_inc\ucos_ii_ports;..\..\src\ucos_inc\ucos_ii_ports\ARM-Cortex-M4\RealView
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ../../src/app/: main.c led.c
  group cmsis
    ../../src/ucos_inc/mcu/CMSIS_M4/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group stm32f4xx
    ../../src/ucos_inc/mcu/STM32F4XX/: stm32f4xx.h stm32f4xx_conf.h system_stm32f4xx.h
  group stm32f4xx_std_periph
    ../../src/ucos_inc/mcu/STM32F4xx_DSP_StdPeriph/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_cec.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dfsdm.h stm32f4xx_dma.h stm32f4xx_dma2d.h stm32f4xx_dsi.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_flash_ramfunc.h stm32f4xx_fmc.h stm32f4xx_fmpi2c.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_lptim.h stm32f4xx_ltdc.h stm32f4xx_pwr.h stm32f4xx_qspi.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sai.h stm32f4xx_sdio.h stm32f4xx_spdifrx.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
  group ucos_ii/cfg
    ../../src/ucos_inc/ucos_ii_cfg/: app_cfg.h cpu_cfg.h lib_cfg.h os_cfg.h
  group ucos_ii/core
    ../../src/ucos_inc/ucos_ii_core/: ucos_ii.h os.h
  group ucos_ii/cpu
    ../../src/ucos_inc/ucos_ii_cpu/: cpu_core.h cpu_def.h
    ../../src/ucos_inc/ucos_ii_cpu/ARM-Cortex-M4/RealView/: cpu.h
  group ucos_ii/lib
    ../../src/ucos_inc/ucos_ii_lib/: lib_ascii.h lib_def.h lib_math.h lib_mem.h lib_str.h
  group ucos_ii/port
    ../../src/ucos_inc/ucos_ii_ports/ARM-Cortex-M4/RealView/: os_cpu.h
  group ucos_image
    ../../lib/: stm32f40x_8M.lib
